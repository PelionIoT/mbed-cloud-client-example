# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32L475VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STCubeGenerated +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Inc;  C:/Users/robros01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Inc;  C:/Users/robros01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  C:/Users/robros01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/CMSIS/Device/ST/STM32L4xx/Include;  C:/Users/robros01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/CMSIS/Include;C:/Users/antyli01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Inc;C:/Users/antyli01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;C:/Users/antyli01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/CMSIS/Device/ST/STM32L4xx/Include;C:/Users/antyli01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ./: 
    C:/Users/robros01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
    C:/Users/antyli01/STM32Cube/Repository/STM32Cube_FW_L4_V1.15.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
