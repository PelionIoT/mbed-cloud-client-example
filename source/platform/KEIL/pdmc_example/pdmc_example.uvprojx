# Keil uVision project pdmc_example.uvprojx, settings and files
target pdmc_example (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: pdmc_example
  AfterMake: C:\KEIL_V5\ARM\ARMCC\bin\fromelf.exe --bin --output=objects/pdmc_example.bin objects/pdmc_example.axf
  AfterMake: python tools/combine.py -b tools/mbed-bootloader.bin -a objects/pdmc_example.bin -o objects/pdmc_example_combined.bin -c 0x8400 -d 0x8000
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MBED_CLOUD_APPLICATION_NONSTANDARD_ENTRYPOINT MBED_CONF_APP_DEVELOPER_MODE=1
  c include: .\;.\source;.\source\include;.\source\platform\include;.\source\platform\KEIL\include
  memory RVCT4: ROM 0x8008400 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --symdefs=pdmc_example.obj --verbose
  group pdmc example sources
    ./source/: app_platform_setup.c application_init.cpp blinky.cpp memory_tests.cpp resource.cpp update_ui_example.cpp
    ./source/platform/: pal_plat_rot_insecure.c
    ./source/platform/KEIL/: mcc_common_button_and_led.c mcc_common_setup.c
    ./: main.cpp mbed_cloud_dev_credentials.c Driver_Flash.c update_default_resources.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, IoT Client:Pelion Device Management Client 4.4.0, Security:mbed TLS 2.17.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 1.2.0, CMSIS Driver:WiFi:ISM43362 1.6.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:Flash 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:RNG 1.11.0, Device:STM32Cube HAL:SPI 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.3.1, IoT Utility:Socket:WiFi 1.0.0
